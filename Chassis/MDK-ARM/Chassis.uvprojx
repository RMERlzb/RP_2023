# Keil uVision project Chassis.uvprojx, settings and files
target Chassis (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.16.0
  cpu: IRAM(0x20000000-0x2001BFFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8000000-0x807FFFF)  CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: Chassis +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F407xx ,USE_STDPERIPH_DRIVER,__FPU_PRESENT = 1U,ARM_MATH_CM4,__CC_ARM,__TARGET_FPU_VFP,STM32F407xx
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;..\Application\DriverLayer;..\Application\ProtocolLayer;..\Application\ConfigLayer;..\Application\DeviceLayer\Sensor;..\Application\AlgorithmLayer;..\Application\DeviceLayer\chassis_motor;..\Application\DeviceLayer\chassis;..\Application\DeviceLayer\gimbal;..\Application\DeviceLayer\gimbal_motor;..\Application\DeviceLayer\Imu;..\Drivers\CMSIS\DSP\Include;..\Application\TaskLayer;..\Application\DeviceLayer\shoot_motor;..\Application\DeviceLayer\shoot;..\Application\DeviceLayer\motor;..\Application\DeviceLayer\Servo
  asm include: ..\Core\Inc
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x1c000
  memory RVCT10: RAM 0x2001c000 size 0x4000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c freertos.c can.c dma.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_can.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Drivers/CMSIS/DSP/Include/: arm_math.h
    ../Core/Src/: system_stm32f4xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group Application/Driver
    ../Application/DriverLayer/: drv_can.c drv_can.h drv_uart.c drv_uart.h drv_io.c drv_io.h drv_haltick.c drv_haltick.h
  group Application/Protocol
    ../Application/ProtocolLayer/: rc_protocol.c rc_protocol.h can_protocol.c can_protocol.h imu_protocol.c imu_protocol.h
  group Application/Config
    ../Application/ConfigLayer/: rp_config.c rp_config.h rp_device_config.h rp_driver_config.h rp_user_config.h rp_user_define.h
  group Application/Device
    ../Application/DeviceLayer/Sensor/: rc_sensor.c rc_sensor.h
    ../Application/DeviceLayer/chassis_motor/: chassis_motor.c chassis_motor.h
    ../Application/DeviceLayer/chassis/: chassis.c chassis.h
    ../Application/DeviceLayer/gimbal/: gimbal.c gimbal.h
    ../Application/DeviceLayer/gimbal_motor/: gimbal_motor.c gimbal_motor.h
    ../Application/DeviceLayer/shoot_motor/: shoot_motor.c shoot_motor.h
    ../Application/DeviceLayer/shoot/: shoot.c shoot.h
    ../Application/DeviceLayer/motor/: motor.c motor.h
    ../Application/DeviceLayer/Servo/: Servo.c Servo.h
  group Application/Algorithm
    ../Application/AlgorithmLayer/: rp_math.c rp_math.h pid.c pid.h
  group Application/Task
    ../Application/TaskLayer/: Chassis_Task.c Chassis_Task.h Imu_Task.c Imu_Task.h RC_Heart_Task.c RC_Heart_Task.h RC_Dial_Task.h RC_Dial_Task.c Shoot_Task.c Shoot_Task.h Gimbal_Task.c Gimbal_Task.h
  group Application/Device/Imu
    ../Application/DeviceLayer/Imu/: bmi.c bmi2.c bmi2_common.c bmi2_ois.c bmi270.c bmi270_context.c soft_iic.c
  group RP2023_MyNote
    ../: readme.txt
software components: CMSIS:CORE 4.3.0
